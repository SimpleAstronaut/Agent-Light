# Keil uVision project agent-light.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F042F6Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x1800) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: agent-light +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F042x6
  c misc: --c99 --split_sections
  c include: ..\app;..\Core\Inc;..\USB_Device;..\vendor\STM32CubeF0\Drivers\STM32F0xx_HAL_Driver\Inc;..\vendor\STM32CubeF0\Drivers\CMSIS\Include;..\vendor\STM32CubeF0\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\vendor\STM32CubeF0\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\vendor\STM32CubeF0\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\vendor\STM32CubeF0\Middlewares\Third_Party\FreeRTOS\Source\include;..\vendor\STM32CubeF0\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM0
  asm define: __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  scatter file: .\agent-light.sct
  group Application
    ../app/: app_main.c board.c cobs.c crc16.c display.c protocol.c usb_cdc_guard.c
  group Core
    ../Core/Src/: main.c
    ../MDK-ARM/: startup_stm32f042x6.s
    ../vendor/STM32CubeF0/Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group USB
    ../USB_Device/: usb_device.c usbd_conf.c
    ../vendor/STM32CubeF0/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../vendor/STM32CubeF0/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group FreeRTOS
    ../vendor/STM32CubeF0/Middlewares/Third_Party/FreeRTOS/Source/: tasks.c list.c
    ../vendor/STM32CubeF0/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
  group HAL
    ../vendor/STM32CubeF0/Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_ll_usb.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F042F6Px STMicroelectronics
  cpu: as above
  output: agent-light +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F042x6,NDEBUG
  c misc: --c99 --split_sections
  c include: as above
  asm define: __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  scatter file: .\agent-light.sct
